options:
  parameters:
    author: muaddib
    generate_options: no_gui
    id: fft_receiver
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: app_vars
  id: snippet
  parameters:
    code: |-
      self.app = Bottle()
      self.connections = set()
      self.opts = {}
      self.fft_broadcast.set_tb(self)
    priority: '1'
    section: main_after_init
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: fft_broadcast
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import json

      class fft_broadcast_sink(gr.sync_block):
          def __init__(self, fft_size=4096):
              gr.sync_block.__init__(self,
                                     name="plotter",
                                     in_sig=[(np.float32, fft_size)],
                                     out_sig=[])
              self.tb=None
          def set_tb(self,ext_tb):
              self.tb=ext_tb
          def work(self, input_items, output_items):
              ninput_items = len(input_items[0])

              for bins in input_items[0]:
                  p = np.around(bins).astype(int)
                  p = np.fft.fftshift(p)
                  for c in self.tb.connections.copy():
                      try:
                          c.send(json.dumps({'s': p.tolist()}, separators=(',', ':')))
                      except Exception:
                          self.tb.connections.remove(c)

              self.consume(0, ninput_items)

              return 0
    fft_size: fft_size
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 750e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: eng_float
    value: '40.0'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import json
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gevent.pywsgi import WSGIServer
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from geventwebsocket import WebSocketError
  states: {}
- name: import_3
  id: import
  parameters:
    imports: from geventwebsocket.handler import WebSocketHandler
  states: {}
- name: import_4
  id: import
  parameters:
    imports: import argparse
  states: {}
- name: import_5
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_6
  id: import
  parameters:
    imports: from bottle import request, Bottle, abort, static_file
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: '30'
    ref_scale: '1'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: server
  id: snippet
  parameters:
    code: |-
      server = WSGIServer(("0.0.0.0", 8000), self.app,
                          handler_class=WebSocketHandler)
      try:
          server.serve_forever()
      except Exception:
          sys.exit(0)

      self.opts['center'] = self.frequency
      self.opts['span'] = self.samp_rate
    priority: '1'
    section: main_after_start
  states: {}
- name: usrp
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    gain0: '30.0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: websocket
  id: snippet
  parameters:
    code: |-
      @self.app.route('/websocket')
      def handle_websocket():
          wsock = request.environ.get('wsgi.websocket')
          if not wsock:
              abort(400, 'Expected WebSocket request.')

          self.connections.add(wsock)

          # Send center frequency and span
          wsock.send(json.dumps(self.opts))

          while True:
              try:
                  wsock.receive()
              except WebSocketError:
                  break

          self.connections.remove(wsock)


      @self.app.route('/')
      def index():
          return static_file('index.html', root='.')


      @self.app.route('/<filename>')
      def static(filename):
          return static_file(filename, root='.')
    priority: '1'
    section: main_after_init
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', fft_broadcast, '0']
- [usrp, '0', logpwrfft_x_0, '0']

metadata:
  file_format: 1
